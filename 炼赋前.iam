# Autodesk Inventor assembly: 조립품
## iProperties
Created: 2014-12
Part Number: 조립품
Document SubType Name: Assembly
Designer: tw009
Author: tw009
